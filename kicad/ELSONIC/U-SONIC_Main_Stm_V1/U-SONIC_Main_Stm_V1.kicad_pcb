# Repository SungKeun-Kim/Embedded_Project

## KiCad design kicad/ELSONIC/U-SONIC_Main_Stm_V1/U-SONIC_Main_Stm_V1.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7, C10, C30, C32, C33, C34, C39, C40, C42, C43, C46, C47: CL21B104K; C_2012Metric; LCSC C1711
C5: CL21C101J; C_2012Metric; LCSC C1790
C8, C12, C14, C21, C22: CL31B105K; C_3216Metric; LCSC C1848
C9, C23, C25, C27, C29, C35, C37, C38: CL31B104K; C_3216Metric; LCSC C24497
C11, C28, C31: CL31B475K; C_3216Metric; LCSC C1872
C13, C15, C24, C36, C44: 10UF25V67RV; CP_Elec_4x5.4; LCSC C2895271
C16, C17: CG330J; C_2012Metric; LCSC C157687
C18, C26: 22pF; C_3216Metric; LCSC C1896
C19, C20: CG220J; C_2012Metric; LCSC C24658
C41: CL31B106K; C_3216Metric; LCSC C307369
C45: CL31B105K; C_3216Metric; LCSC C13832
D1, D6: UF4007; D_SMA; LCSC C81191
D2, D4, D8, D10, D14: LL4148; LL4148_MELF; LCSC C68883
D3, D5, D7, D9, D11, D12: BAT54WSQ-7; D_SOD-323_HandSoldering; LCSC C171824
D13, D15: LL4148; LL4148_MELF; LCSC C84062
FB1: CBG321609U; R_3216Metric; LCSC C74486
H1, H2, H3, H4: MountingHole_Pad; MTHole_3.5mm_6.8mmPad_GND
J1: ARM_SWD_10; IDC-Header_2x05_P2.54mm_Vertical
J2, J7: SMW250-04P; SMW250_04P
J3: SMW250-02P; SMW250_02P
J4: SW_BD
J5: SMW250-06P; SMW250_06P
J6: SMW250-08P; SMW250_08P
J8: RS485_BD; IDC-Header_2x05_P2.54mm_Vertical
K1, K2: HR92; Relay_SPDT_HsinDa_Y14
LCD1: LC1622; LC1622_1
LED1, LED2: LED_SMD_KT_0805R; LED_2012Metric; LCSC C2295
LS1: MLT-8530; MLT8530; LCSC C94599
OP_1, OP_2, OP_3, OP_4: TAP_250
Q1, Q2: IRF7351; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C5338301
Q3, Q4, Q6: KRC105S; SOT-23_KRC105S; LCSC C112793
Q5: 2SC5343; SOT-23; LCSC C2910220
R1, R2, R30, R31, R32, R38, R39, R45, R48: W8J0103; R_2012Metric; LCSC C25612
R3, R6, R19, R25: RS-06K22R; R_3216Metric; LCSC C140034
R4, R12, R21, R26: RS-06K103JT; R_3216Metric; LCSC C118075
R5, R23, R24, R36: 1K; R_3216Metric; LCSC C131398
R7, R14, R18: 100K/1W; R_6332Metric; LCSC C52842
R8, R15, R33, R35: FRC1206F2400TS; R_3216Metric; LCSC C2933649
R9, R17, R34, R37: 10K; R_3216Metric; LCSC C183193
R10, R13: 0805FR-0747RL; R_2012Metric; LCSC C114541
R11: WR08X1000FTL; R_2012Metric; LCSC C163954
R16, R20, R22, R28: WR08X1002FTL; R_2012Metric; LCSC C108451
R27: RS-05K472JT; R_2012Metric; LCSC C115310
R29: RS-06K47R; R_3216Metric; LCSC C140014
R40, R46, R49: RS-05K470JT; R_2012Metric; LCSC C139871
R42, R44: 0805W8J0202T5E; R_2012Metric; LCSC C1359
R43: 0805W8F1000T; R_2012Metric; LCSC C17408
R47: RS-05K471JT; R_2012Metric; LCSC C119076
RV1: 3362P103; TRIM_3362P
T1: SCT-17P
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TPOINT; TP
TR1: EI2218
U1: 74AHCT125; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C842299
U2, U4: IR2104; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2960
U3: STM32G474CBT6; LQFP-48_7x7mm_P0.5mm; LCSC C730123
U5: 74HCT574PWR; TSSOP-20_4.4x6.5mm_P0.65mm; LCSC C2652839
U6: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186
Y1: X49SM8M; Crystal_SMD_HC49-SD; LCSC C106809

Connections:
+3.3V: C1.2, C2.2, C3.2, C4.2, C30.2, C31.2, C43.2, C44.1, D3.1 (K), D7.1 (K), D11.1 (K), D14.1 (K), FB1.1, J1.1, J1.7, J6.8, LS1.2 (+LEAD), R1.2, R2.2, R9.2, R27.2, R28.2, R30.2, R31.2, R32.2, R34.2, R38.2, R39.2, R42.2, R45.2, R48.2, U3.1 (VBAT), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U6.2 (VO)
+5V: C27.2, C28.2, C29.2, C41.2, C42.2, D13.1 (K), D15.1 (K), J1.8, J5.3, J8.1, J8.2, K1.3, K2.3, LCD1.2 (VDD), R29.2, R44.2, RV1.1, U1.14 (VCC), U5.20 (VCC), U6.3 (VI)
+12V: C12.2, C13.1, C14.2, C15.1, C21.2, D1.2 (A), D6.2 (A), J5.1, Q1.7 (D1), Q1.8 (D1), Q2.7 (D1), Q2.8 (D1), U2.1 (VCC), U4.1 (VCC)
/50V_550V_15kHz_128kHz: OP_1.1, OP_1.2, OP_2.1, OP_2.2, R7.2
/485BD_DETECT: J8.8, R28.1, U3.40 (PB3)
/ADC1_IN1_COMP3: C26.2, D7.2 (A), D9.1 (K), R23.2, TP5.1 (Pin_1_1), U3.8 (PA0)
/ADC1_IN2_COMP1: C18.2, D3.2 (A), D5.1 (K), R5.1, TP3.1 (Pin_1_1), U3.9 (PA1)
/ADC2_IN3: C38.2, D11.2 (A), D12.1 (K), R36.1, TP1.1 (Pin_1_1), U3.14 (PA6)
/BZ_OUT: Q3.1 (B), U3.13 (PA5)
/CHA1: R10.1, U3.30 (PA8)
/CHA2: R13.1, U3.31 (PA9)
/CLK_LCD: U3.16 (PB0), U5.11 (Cp)
/DE_RS485: J8.6, R20.2, U3.41 (PB4)
/DOWN: C34.1, J4.3, R32.1, U3.44 (PB7)
/END_BZ: Q6.1 (B), U3.3 (PC14)
/GOING: Q4.1 (B), U3.2 (PC13)
/INA: C19.2, R10.2, U1.2
/INB: C20.2, R13.2, U1.5
/LCD_D4: U3.26 (PB12), U5.4 (D2)
/LCD_D5: U3.27 (PB13), U5.5 (D3)
/LCD_D6: U3.28 (PB14), U5.6 (D4)
/LCD_D7: U3.29 (PB15), U5.7 (D5)
/LCD_E: U3.25 (PB11), U5.2 (D0)
/LCD_RS: U3.22 (PB10), U5.3 (D1)
/MAX485_RX: J8.3, U1.13
/MAX485_TX: J8.5, U1.8
/MODE: C39.1, J4.4, R38.1, U3.43 (PB6)
/NRST: C7.2, J1.10, R2.1, U3.7 (PG10)
/PWM_COLLECTOR: J5.6, Q5.3 (C)
/PWM_OUTPUT: R47.2, U3.15 (PA7)
/PWM_VR: C45.2, R43.1, U3.17 (PB1)
/REMOTE: C46.1, R45.1, R46.1, U3.32 (PA10)
/RTERM: J8.7, U3.18 (PB2)
/RUN_LED: LED1.2 (K), U3.12 (PA4)
/RUN_SW: C40.1, R39.1, R40.1, U3.33 (PA11)
/SONIC_ON: R11.1, U3.39 (PA15)
/SPARE: J8.9, U3.4 (PC15)
/START_STOP: C32.1, J4.1, R30.1, U3.46 (PB9)
/SWCLK: J1.4, U3.38 (PA14)
/SWDIO: C5.2, J1.2, R1.1, U3.37 (PA13)
/SWEEP_SW: C47.1, R48.1, R49.1, U3.34 (PA12)
/UP: C33.1, J4.2, R31.1, U3.45 (PB8)
/USART2_RX: R27.1, U1.11, U3.11 (PA3)
/USART2_TX: U1.9, U3.10 (PA2)
//RE_RS485: J8.4, R22.2, U3.42 (PB5)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C10.1, C11.1, C12.1, C13.2, C14.1, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C24.2, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.2, C33.2, C34.2, C35.1, C36.2, C37.1, C38.1, C39.2, C40.2, C41.1, C42.1, C43.1, C44.2, C45.1, C46.2, C47.2, D5.2 (A), D9.2 (A), D12.2 (A), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), J1.3, J1.9, J4.5, J4.6, J4.7, J4.8, J5.2, J5.4, J6.1, J6.3, J6.5, J8.10, LCD1.1 (VSS), LCD1.5 (R/W), LCD1.16 (LED(-)), LCD1.17, LCD1.18, LCD1.19, LCD1.20, LED2.2 (K), Q1.3 (S2), Q2.3 (S2), Q3.2 (E), Q4.2 (E), Q5.2 (E), Q6.2 (E), R12.1, R16.1, R17.1, R20.1, R22.1, R26.1, R37.1, RV1.3, TP2.1 (Pin_1_1), TP4.1 (Pin_1_1), TP6.1 (Pin_1_1), TP8.1 (Pin_1_1), TP10.1 (Pin_1_1), U1.1, U1.4, U1.7 (GND), U1.10, U1.12, U2.4 (COM), U3.19 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.4 (COM), U5.1 (OE), U5.10 (GND), U6.1 (GND)
unnamed: C24.1, C25.2, R8.1, R9.1, R15.1, R17.2, R24.1, T1.4
unnamed: C36.1, C37.2, J3.2, R33.1, R34.1, R35.1, R37.2
unnamed: C8.2, C9.2, D1.1 (K), U2.8 (VB)
unnamed: D2.2 (A), Q1.2 (G1), R3.2, R4.2
unnamed: D2.1 (K), R3.1, U2.7 (HO)
unnamed: D4.2 (A), Q1.4 (G2), R6.2, R12.2
unnamed: D4.1 (K), R6.1, U2.5 (LO)
unnamed: C22.2, C23.2, D6.1 (K), U4.8 (VB)
unnamed: D8.2 (A), Q2.2 (G1), R19.2, R21.2
unnamed: D8.1 (K), R19.1, U4.7 (HO)
unnamed: D10.2 (A), Q2.4 (G2), R25.2, R26.2
unnamed: D10.1 (K), R25.1, U4.5 (LO)
unnamed: D13.2 (A), K1.4, Q4.3 (C)
unnamed: D14.2 (A), LS1.3 (-LEAD), Q3.3 (C)
unnamed: D15.2 (A), K2.4, Q6.3 (C)
unnamed: J2.1, TR1.6
unnamed: J2.2, TR1.7
unnamed: J2.3, TR1.9
unnamed: J2.4, TR1.10
unnamed: J3.1, R33.2, R35.2, R36.2
unnamed: J6.2, R49.2
unnamed: J6.4, R43.2
unnamed: J6.6, R46.2
unnamed: J6.7, R40.2
unnamed: J7.1, K1.5, K1.6
unnamed: J7.2, K1.1
unnamed: J7.3, K2.5, K2.6
unnamed: J7.4, K2.1
unnamed: LCD1.11 (D4), U5.17 (Q2)
unnamed: LCD1.12 (D5), U5.16 (Q3)
unnamed: LCD1.13 (D6), U5.15 (Q4)
unnamed: LCD1.14 (D7), U5.14 (Q5)
unnamed: LCD1.6 (E), U5.18 (Q1)
unnamed: LCD1.15 (LED(+)), R29.1
unnamed: LCD1.4 (RS), U5.19 (Q0)
unnamed: C35.2, LCD1.3 (VO), RV1.2
unnamed: LED1.1 (A), R42.1
unnamed: LED2.1 (A), R44.1
unnamed: OP_3.1, OP_3.2, OP_4.1, OP_4.2
unnamed: C8.1, C9.1, Q1.1 (S1), Q1.5 (D2), Q1.6 (D2), R4.1, TP11.1 (Pin_1_1), TR1.2, U2.6 (VS)
unnamed: C22.1, C23.1, Q2.1 (S1), Q2.5 (D2), Q2.6 (D2), R21.1, TP12.1 (Pin_1_1), TR1.4, U4.6 (VS)
unnamed: Q5.1 (B), R47.1
unnamed: R14.1, R18.2
unnamed: R7.1, R14.2
unnamed: R5.2, R8.2, R15.2, T1.3
unnamed: R18.1, R23.1, R24.2
unnamed: TP7.1 (Pin_1_1), U1.3, U2.2 (IN)
unnamed: TP9.1 (Pin_1_1), U1.6, U4.2 (IN)
unnamed: R11.2, R16.2, U2.3 (~SD), U4.3 (~SD)
unnamed: C16.2, U3.5 (PF0), Y1.2
unnamed: C17.2, U3.6 (PF1), Y1.1
unnamed: C6.2, C10.2, C11.2, FB1.2, U3.20 (VREF+), U3.21 (VDDA)

Notes on the sheet:
10(ID)16(OD)SN-02HT CT 1:1000T
10(ID)16(OD)CT 1:1000T
1.618V
PA2 TX ── 74AHCT125 ── MAX485 DI PA3 RX ◀─ 3.3V LVC 버퍼 ◀─ MAX485 RO PB4 DE ────────────────── MAX485 DE PB5 /RE ───────────────── MAX485 /RE PB2 RTERM ──────────────── KRC105M PB3 DETECT ◀────────────── SPARE1
PA2 TX ── 74AHCT02 ── MAX485 DI PA3 RX ◀─ 3.3V LVC 버퍼 ◀─ MAX485 RO PB4 DE ────────────────── MAX485 DE PB5 /RE ───────────────── MAX485 /RE PB2 RTERM ──────────────── KRC105M PB3 DETECT ◀────────────── SPARE1
1.623V

Board: 2 copper layers, 156.0 x 100.0 mm, 161 parts (2 on the bottom side), 98 nets.

File kicad/ELSONIC/U-SONIC_Main_Stm_V1/U-SONIC_Main_Stm_V1_DipParts.xlsx:

NO | Reference | Value | Qty | LCSC
1 | C1,C2,C3,C4,C6,C7,C10,C30,C32, C33,C34,C39,C40,C42,C43,C46,C47 | CL21B104K | 17 | C1711
2 | C5 | CL21C101J | 1 | C1790
3 | C8,C12,C14,C21,C22 | CL31B105K | 5 | C1848
4 | C9,C23,C25,C27,C29,C35,C37,C38 | CL31B104K | 8 | C24497
5 | C11,C28,C31 | CL31B475K | 3 | C1872
6 | C13,C15,C24,C36,C44 | 10UF25V67RV | 5 | C2895271
7 | C16,C17 | CG330J | 2 | C157687
8 | C18,C26 | 22pF | 2 | C1896
9 | C19,C20 | CG220J | 2 | C24658
10 | C41 | CL31B106K | 1 | C307369
11 | C45 | CL31B105K | 1 | C13832
12 | D1,D6 | UF4007 | 2 | C81191
13 | D2,D4,D8,D10,D14 | LL4148 | 5 | C68883
14 | D3,D5,D7,D9,D11,D12 | BAT54WSQ-7 | 6 | C171824
15 | D13,D15 | LL4148 | 2 | C84062
16 | FB1 | CBG321609U | 1 | C74486
17 | J1 | ARM_SWD_10 | 1
18 | J2,J7 | SMW250-04P | 2
19 | J3 | SMW250-02P | 1
20 | J4 | SW_BD | 1
21 | J5 | SMW250-06P | 1
22 | J6 | SMW250-08P | 1
23 | J8 | RS485_BD | 1
24 | K1,K2 | HR92 | 2
25 | LCD1 | LC1622 | 1
26 | LED1,LED2 | LED_SMD_KT_0805R | 2 | C2295
27 | LS1 | MLT-8530 | 1 | C94599
28 | OP_1,OP_2,OP_3,OP_4 | TAP_250 | 4
29 | Q1,Q2 | IRF7351 | 2 | C5338301
30 | Q3,Q4,Q6 | KRC105S | 3 | C112793
31 | Q5 | 2SC5343 | 1 | C2910220
32 | R1,R2,R30,R31,R32,R38,R39,R45,R48 | W8J0103 | 9 | C25612
33 | R3,R6,R19,R25 | RS-06K22R | 4 | C140034
34 | R4,R12,R21,R26 | RS-06K103JT | 4 | C118075
35 | R5,R23,R24,R36 | 1K | 4 | C131398
36 | R7,R14,R18 | 100K/1W | 3 | C52842
37 | R8,R15,R33,R35 | FRC1206F2400TS | 4 | C2933649
38 | R9,R17,R34,R37 | 10K | 4 | C183193
39 | R10,R13 | 0805FR-0747RL | 2 | C114541
40 | R11 | WR08X1000FTL | 1 | C163954
41 | R16,R20,R22,R28 | WR08X1002FTL | 4 | C108451
42 | R27 | RS-05K472JT | 1 | C115310
43 | R29 | RS-06K47R | 1 | C140014
44 | R40,R46,R49 | RS-05K470JT | 3 | C139871
45 | R42,R44 | 0805W8J0202T5E | 2 | C1359
46 | R43 | RS-05L1R0JT | 1 | C304860
47 | R47 | RS-05K471JT | 1 | C119076
48 | RV1 | 3362P103 | 1
49 | T1 | SCT-17P | 1
50 | TP1,TP2,TP3,TP4,TP5,TP6,TP7,TP8, TP9,TP10,TP11,TP12 | TPOINT | 12
51 | TR1 | EI2218 | 1
52 | U1 | 74AHCT125 | 1 | C842299
53 | U2,U4 | IR2104 | 2 | C2960
54 | U3 | STM32G474CBT6 | 1 | C730123
55 | U5 | 74HCT574PWR | 1 | C2652839
56 | U6 | AMS1117-3.3 | 1 | C6186
57 | Y1 | X49SM8M | 1 | C106809

## KiCad design kicad/ELSONIC/exam_uno_01/exam_uno_01.kicad_pcb

Board: 2 copper layers, 68.6 x 53.3 mm, 8 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J3: Analog; PinSocket_1x06_P2.54mm_Vertical
J4: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
MH1, MH2, MH3, MH4: MountingHole_3.2mm

Connections:
/SCL/A5: J2.1, J3.6
/SDA/A4: J2.2, J3.5
GND: J1.6, J1.7, J2.4
